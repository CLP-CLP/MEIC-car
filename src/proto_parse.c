/**
 ******************************************************************************
 * @file    proto_parse.c
 * @brief   协议解析器：6 状态、逐字节、非阻塞（严格按 PROTOCOL.md 第 7.2 节）
 *
 *  本文件是纯逻辑，不依赖 HAL，可以在 PC 上编译做单元测试。
 *  状态含义 = "下一个字节应该是什么"：
 *      等帧头1 -> 等帧头2 -> 等类型 -> 等长度 -> 等负载 -> 等校验
 *
 *  重同步规则：校验失败或 LEN 非法时，如果出问题的那个字节本身是 0xAA，
 *  就把它当成新帧头的第一个字节（进入 等帧头2），否则回到 等帧头1。
 *  这样"线上丢了一个字节"（AA AA 55 ...）不会连带吃掉下一帧。
 ******************************************************************************
 */

/* Includes ------------------------------------------------------------------*/
#include "proto.h"

/* ============================== 私有类型 =================================== */

typedef enum
{
    等帧头1 = 0,
    等帧头2,
    等类型,
    等长度,
    等负载,
    等校验
} 解析状态;

/* ============================== 私有变量 =================================== */

static 解析状态 状态 = 等帧头1;

static uint8_t 本帧类型 = 0U;
static uint8_t 本帧长度 = 0U;
static uint8_t 本帧负载[协议_负载上限];
static uint8_t 已收字节 = 0U;

static 协议_结果 最新;

static uint32_t 好帧数 = 0U;
static uint32_t 错帧数 = 0U;
static uint32_t 未知类型数 = 0U;
static uint32_t 长度错数 = 0U;

/* 诊断用：线上到底来过什么 */
static uint32_t 字节总数 = 0U;
static uint8_t  最近字节[协议_最近字节数];
static uint8_t  最近写位置 = 0U;        /* 下一个要写的位置 = 最老的字节 */

/* ============================== 私有函数 =================================== */

/**
  * @brief  逐字节异或校验
  */
static uint8_t 算校验(uint8_t 类型, const uint8_t *负载, uint8_t 长度)
{
    uint8_t 校验 = (uint8_t)(类型 ^ 长度);
    uint8_t i;

    for (i = 0U; i < 长度; i++) {
        校验 = (uint8_t)(校验 ^ 负载[i]);
    }

    return 校验;
}

/**
  * @brief  重同步：按"出问题的那个字节"决定下一个状态
  */
static void 重同步(uint8_t 字节)
{
    状态 = (字节 == 协议_帧头1) ? 等帧头2 : 等帧头1;
}

/**
  * @brief  处理一整帧（此时校验已通过）
  */
static void 处理整帧(void)
{
    if (本帧类型 == 协议_类型状态)
    {
        if (本帧长度 == 4U)
        {
            最新.有效     = 1U;
            最新.状态     = 本帧负载[0];
            最新.停车点   = 本帧负载[1];
            最新.罗马数字 = 本帧负载[2];
            最新.序号     = 本帧负载[3];
            好帧数++;
        }
        else
        {
            /* STATUS 长度不对：整帧丢弃，绝不动"最新结果" */
            错帧数++;
        }
    }
    else if (本帧类型 == 协议_类型文本)
    {
        /* 调试文本：接收端可以完全不处理，这里只是留着打印用 */
    }
    else
    {
        /* 未知类型：忽略（只记数），既不算错误，也不能让解析器卡住 */
        未知类型数++;
    }
}

/* ============================== 对外接口 =================================== */

void 协议_解析喂字节(uint8_t 字节)
{
    /* 先记原始字节：哪怕整帧都解不出来，也要知道线上来过东西 */
    字节总数++;
    最近字节[最近写位置] = 字节;
    最近写位置 = (uint8_t)((最近写位置 + 1U) % 协议_最近字节数);

    switch (状态)
    {
        case 等帧头1:
            if (字节 == 协议_帧头1) {
                状态 = 等帧头2;
            }
            break;

        case 等帧头2:
            if (字节 == 协议_帧头2) {
                状态 = 等类型;
            } else if (字节 == 协议_帧头1) {
                /* 连续来两个 0xAA：留在本状态继续等 0x55 */
            } else {
                状态 = 等帧头1;
            }
            break;

        case 等类型:
            本帧类型 = 字节;
            状态 = 等长度;
            break;

        case 等长度:
            if (字节 > 协议_负载上限) {
                /* LEN 超上限：丢帧 + 重同步（防缓冲越界的唯一一道关） */
                长度错数++;
                错帧数++;
                重同步(字节);
            } else {
                本帧长度 = 字节;
                已收字节 = 0U;
                状态 = (本帧长度 == 0U) ? 等校验 : 等负载;
            }
            break;

        case 等负载:
            本帧负载[已收字节] = 字节;
            已收字节++;
            if (已收字节 >= 本帧长度) {
                状态 = 等校验;
            }
            break;

        case 等校验:
        default:
            if (字节 == 算校验(本帧类型, 本帧负载, 本帧长度)) {
                处理整帧();
                状态 = 等帧头1;
            } else {
                错帧数++;
                重同步(字节);
            }
            break;
    }
}

void 协议_解析取结果(协议_结果 *结果)
{
    if (结果 == 0) {
        return;
    }

    结果->有效     = 最新.有效;
    结果->状态     = 最新.状态;
    结果->停车点   = 最新.停车点;
    结果->罗马数字 = 最新.罗马数字;
    结果->序号     = 最新.序号;
}

void 协议_解析清零(void)
{
    uint8_t i;

    状态     = 等帧头1;
    本帧类型 = 0U;
    本帧长度 = 0U;
    已收字节 = 0U;

    for (i = 0U; i < 协议_负载上限; i++) {
        本帧负载[i] = 0U;
    }

    最新.有效     = 0U;
    最新.状态     = 0U;
    最新.停车点   = 0U;
    最新.罗马数字 = 0U;
    最新.序号     = 0U;

    好帧数     = 0U;
    错帧数     = 0U;
    未知类型数 = 0U;
    长度错数   = 0U;

    字节总数   = 0U;
    最近写位置 = 0U;

    for (i = 0U; i < 协议_最近字节数; i++) {
        最近字节[i] = 0U;
    }
}

uint32_t 协议_解析好帧数(void)      { return 好帧数; }
uint32_t 协议_解析错帧数(void)      { return 错帧数; }
uint32_t 协议_解析未知类型数(void)  { return 未知类型数; }
uint32_t 协议_解析长度错数(void)    { return 长度错数; }
uint32_t 协议_解析字节总数(void)    { return 字节总数; }

void 协议_解析最近字节(uint8_t *缓冲)
{
    uint8_t i;

    if (缓冲 == 0) {
        return;
    }

    /* 最近写位置 指向最老的那个字节，从它开始读就是时间顺序 */
    for (i = 0U; i < 协议_最近字节数; i++) {
        缓冲[i] = 最近字节[(uint8_t)((最近写位置 + i) % 协议_最近字节数)];
    }
}
